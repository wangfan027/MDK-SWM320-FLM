# Keil uVision project NewDevice.uvprojx, settings and files
target SWM320_W25Q64_8MBytes_ExFlash (6190000::V6.19::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.20.4
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: SWM32W25Q64_8MBytes
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\_Template_Flash;.\SWM320_StdPeriph_Driver
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Driver
    ./: system_SWM320.c W25Q64.c
    ./SWM320_StdPeriph_Driver/: SWM320_spi.c SWM320_gpio.c SWM320_port.c SWM320_flash.c
